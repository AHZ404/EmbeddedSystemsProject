# IAR project HMI.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C123GH6PM
  ICCARM.CCIncludePath2: D:\Programs\ti; D:\Programs\ti\inc; D:\Programs\ti\driverlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HMI.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.axf
  ILINK.IlinkAdditionalLibs: D:\Programs\ti\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    ./: adc.c adc.h dio.c dio.h keypad.c keypad.h lcd.c lcd.h main.c startup_ewarm.c systick.c systick.h test_integration.c tm4c123gh6pm.h uart.c uart.h
