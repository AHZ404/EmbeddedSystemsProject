<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Tiva 1\Tiva 1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Tiva 2\Tiva 2.ewp</path>
    </project>
    <batchBuild />
</workspace>
